options:
  parameters:
    generate_options: qt_gui
    id: test_angle_of_arrival
    output_language: python
    title: test_angle_of_arrival
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: howto_angle_of_arrival_ff_0
  id: howto_angle_of_arrival_ff
  parameters:
    A0: '90'
    A1: '-180/np.pi'
    D: '1'
    k: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', howto_angle_of_arrival_ff_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [howto_angle_of_arrival_ff_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
