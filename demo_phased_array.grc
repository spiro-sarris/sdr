options:
  parameters:
    generate_options: qt_gui
    id: demo_phased_array
    output_language: python
    qt_qss_theme: /home/ssarris/src/sdr/dark.qss
    title: Phased Array Demo
  states: {}

blocks:
- name: D_length_m
  id: variable
  parameters:
    value: wavelength/2
  states: {}
- name: aoa_deg_b
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Angle of Arrival [deg]
    min_len: '1'
    orient: Qt.Horizontal
    start: '-90'
    step: '5'
    stop: '90'
    value: '0'
  states: {}
- name: aoa_rad_h
  id: variable
  parameters:
    value: (aoa_deg_b+90)*np.pi/180.0
  states: {}
- name: beam_steer_deg_b
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Beam Steer Angle [deg]
    min_len: '1'
    orient: Qt.Horizontal
    start: '-90'
    step: '5'
    stop: '90'
    value: '0'
  states: {}
- name: beam_steer_rad_h
  id: variable
  parameters:
    value: (beam_steer_deg_b+90)*np.pi/180.0
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: samp_rate/10
  states: {}
- name: freq_rf
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: gui_update_sec
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: k_rad_per_m
  id: variable
  parameters:
    value: 2*np.pi*freq/speed_of_light
  states: {}
- name: n_cycles
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nskip
  id: variable
  parameters:
    value: '103'
  states: {}
- name: phase_shift_rad
  id: variable
  parameters:
    value: k_rad_per_m * D_length_m * np.cos(aoa_rad_h)
  states: {}
- name: phase_steer_rad
  id: variable
  parameters:
    value: '-1*k_rad_per_m * D_length_m * np.cos(beam_steer_rad_h)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: speed_of_light
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: speed_of_light/freq
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: phase_steer_rad
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/np.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1/(2*np.pi)'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fft_bin_select_0
  id: fft_bin_select
  parameters:
    fft_size: fft_size
    nskip: nskip
  states: {}
- name: fft_bin_select_0_0
  id: fft_bin_select
  parameters:
    fft_size: fft_size
    nskip: nskip
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    size: '1'
    type: complex
    update_time: gui_update_sec
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"yellow"'
    color2: '"cyan"'
    color3: '"magenta"'
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,2,1
    label1: Antenna 1
    label2: Antenna 2
    label3: Array Beam
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 4,0,1,1
    label1: RXA
    label2: RXB
    name: Magnitude (dB)
    nconnections: '2'
    type: float
    unit1: dB
    unit2: dB
    update_time: gui_update_sec
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 4,1,1,1
    label1: Magnitude (dB)
    label2: Phase (deg)
    name: Difference A-B
    nconnections: '2'
    type: float
    unit1: dB
    unit2: degrees
    update_time: gui_update_sec
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,2,1
    nconnections: '2'
    size: int(n_cycles*samp_rate/freq)
    srate: samp_rate
    type: float
    update_time: gui_update_sec
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: to_mag_db_0
  id: to_mag_db
  parameters: {}
  states: {}
- name: to_mag_db_0_0
  id: to_mag_db
  parameters: {}
  states: {}
- name: to_mag_db_0_0_0
  id: to_mag_db
  parameters: {}
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq_rf
    center_freq1: freq_rf
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '"master_clock_rate=125e6"'
    gain0: '70'
    gain1: '70'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_2, '0', qtgui_freq_sink_x_0, '2']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_divide_xx_0, '0', to_mag_db_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_2, '1']
- [fft_bin_select_0, '0', blocks_divide_xx_0, '0']
- [fft_bin_select_0, '0', to_mag_db_0_0, '0']
- [fft_bin_select_0_0, '0', blocks_divide_xx_0, '1']
- [fft_bin_select_0_0, '0', to_mag_db_0_0_0, '0']
- [to_mag_db_0, '0', qtgui_number_sink_0_0_0, '0']
- [to_mag_db_0_0, '0', qtgui_number_sink_0_0, '0']
- [to_mag_db_0_0_0, '0', qtgui_number_sink_0_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_add_xx_2, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0_0, '0', fft_bin_select_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_complex_to_real_1, '0']
- [uhd_usrp_source_0_0, '1', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0_0, '1', fft_bin_select_0_0, '0']
- [uhd_usrp_source_0_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
