options:
  parameters:
    description: Complex to Magnitude dB
    generate_options: hb
    id: to_mag_db
    output_language: python
  states: {}

blocks:
- name: blocks_complex_to_mag_0_4
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0_4, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_0_4, '0']

metadata:
  file_format: 1
