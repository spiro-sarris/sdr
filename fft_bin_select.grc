options:
  parameters:
    description: Select signal from fft bin of choice
    generate_options: hb
    id: fft_bin_select
    output_language: python
    title: FFT Bin Select
  states: {}

blocks:
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./fft_size
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/fft_size
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: nskip
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    type: intx
    value: '64'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hann(fft_size)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: nskip
  id: parameter
  parameters:
    label: nskip
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: bin
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: full_spectrum
    type: complex
  states: {}

connections:
- [blocks_keep_one_in_n_1_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_skiphead_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_skiphead_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
