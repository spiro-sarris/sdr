<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>holorx_host</value></param>
<param><key>author</key><value>Spiro Sarris</value></param>
<param><key>description</key><value>Phase and Path Length Difference of Two Receiver Channels</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Holo RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>client_address</value></param>
<param><key>value</key><value>"192.168.10.184"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_rftune</value></param>
<param><key>value</key><value>70e6</value></param>
<param><key>gui_hint</key><value>tabs@0:3,0,1,1</value></param>
<param><key>label</key><value>Freq RF Tune</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>10e6</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>6e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rxa</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,0,1,1</value></param>
<param><key>label</key><value>Gain RXA</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>80</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rxb</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:2,0,1,1</value></param>
<param><key>label</key><value>Gain RXB</value></param>
<param><key>min_len</key><value>1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>80</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_update_sec</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_baseband_samp_freq</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Baseband Sample Frequency (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_binwidth_hz</value></param>
<param><key>value</key><value>samp_rate/fft_size</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>FFT Bin Width (Hz) </value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_fftsize</value></param>
<param><key>value</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_results_per_second</value></param>
<param><key>value</key><value>samp_rate/fft_size</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>FFT Results Per Second </value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seconds_record</value></param>
<param><key>value</key><value>7200</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>test2hrs.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>int(seconds_record*samp_rate/fft_size)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>180/np.pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fft_bin_select</key>
<param><key>id</key><value>fft_bin_select_A</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>nskip</key><value>1</value></param>
</block>
<block>
<key>fft_bin_select</key>
<param><key>id</key><value>fft_bin_select_B</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>nskip</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>fft_size</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>tabs@0:0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>RXA</value></param>
<param><key>label2</key><value>RXB</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>gui_update_sec</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
<param><key>label</key><value>FFT Amplitude</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,1,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>RXA</value></param>
<param><key>unit1</key><value>dB</value></param>
<param><key>label2</key><value>RXB</value></param>
<param><key>unit2</key><value>dB</value></param>
<param><key>name</key><value>Magnitude (dB)</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>gui_update_sec</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>gui_hint</key><value>tabs@0:3,1,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Magnitude (dB)</value></param>
<param><key>unit1</key><value>dB</value></param>
<param><key>label2</key><value>Phase (deg)</value></param>
<param><key>unit2</key><value>degrees</value></param>
<param><key>name</key><value>Difference A-B</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>gui_update_sec</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>RX 2 Channels</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>to_mag_db</key>
<param><key>id</key><value>to_mag_db_0_0</value></param>
</block>
<block>
<key>to_mag_db</key>
<param><key>id</key><value>to_mag_db_0_1</value></param>
</block>
<block>
<key>to_mag_db</key>
<param><key>id</key><value>to_mag_db_0_3</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client0</value></param>
<param><key>addr</key><value>str(client_address)</value></param>
<param><key>callback</key><value>set_gain_rxb</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>gain_rxb</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client0_0</value></param>
<param><key>addr</key><value>str(client_address)</value></param>
<param><key>callback</key><value>set_freq_rftune</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>freq_rftune</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1</value></param>
<param><key>addr</key><value>str(client_address)</value></param>
<param><key>callback</key><value>set_gain_rxa</value></param>
<param><key>port</key><value>30000</value></param>
<param><key>variable</key><value>gain_rxa</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>tcp://192.168.10.184:9999</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_1</value></param>
<param><key>address</key><value>tcp://192.168.10.184:9998</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>to_mag_db_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_bin_select_A</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_bin_select_A</source_block_id><sink_block_id>to_mag_db_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_bin_select_B</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_bin_select_B</source_block_id><sink_block_id>to_mag_db_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_mag_db_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_mag_db_0_1</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>to_mag_db_0_3</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>fft_bin_select_B</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_1</source_block_id><sink_block_id>fft_bin_select_A</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
