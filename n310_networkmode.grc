options:
  parameters:
    author: Spiro Sarris
    copyright: LGPL
    description: Test basic network mode communication with N310 2 channels
    generate_options: qt_gui
    id: n310_networkmode
    output_language: python
    qt_qss_theme: /home/ssarris/src/sdr/dark.qss
    title: n310_networkmode
  states: {}

blocks:
- name: freq_rf
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rf
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq_rf
    center_freq1: freq_rf
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '"master_clock_rate=125e6"'
    gain0: '50'
    gain1: '50'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
